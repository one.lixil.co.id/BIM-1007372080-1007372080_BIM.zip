Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-09-26T16:08:13
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.80.35 - Exporter 21.1.80.35 - Alternate UI 21.1.80.35
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Sep 26 16:08:13 2023 * Host: CHATPONG-DEE * Database: C:\Users\CHATPONG\AppData\Local\Temp\01662a8f-2223-4c15-b5b5-087a3c4a12b6\fe7e3dbf-42e6-4854-99d8-2544a3a70f51\ifc * Database version: 5507 * Database creation date: Tue Sep 26 16:08:09 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Sep 26 16:08:10 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Sep 26 16:08:10 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcBuildingElementProxy: 1007372080_REVIT:Smart Washer Manual Bidet, 1007372080_REVIT:Smart Washer Manual Bidet:347513
In: Level 1
Type - Material: American Standard - Plastic - Polypropylene
Type - Pset_BuildingElementProxyCommon - Reference: Smart Washer Manual Bidet
Type - Pset_ElementShading - Color: White Heat II
Type - Pset_ManufacturerTypeInformation - Manufacturer: American Standard
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: Smart Washer Manual Bidet
Type - Pset_ProvisionForVoid - Width: 494 mm; Height: 73 mm; Depth: 370 mm
Pset_BuildingElementProxyCommon - sets with these values: 2
